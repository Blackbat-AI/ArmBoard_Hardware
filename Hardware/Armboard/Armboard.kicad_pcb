# Repository Blackbat-AI/ArmBoard_Hardware

File README.md:

# ArmBoardHardware
Hardware design files for robotic arm

Master branch holds completed versions, branch arm board holds works in progress

Requires KiCAD libraries 5.1.7 and MRDT_KiCAD_Libraries 2021 Release 1

## KiCad design Hardware/Armboard/Armboard.kicad_pcb

Parts:
Conn1: AndersonPP; Anderson_3_Horizontal_Side_by_Side
Conn2, Conn3, Conn4, Conn6: AndersonPP; Anderson_2_Vertical_Sidy_by_Side
D2, D3, D4, D5, D6, D7: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R9, R11, R12, R13, R14: 1.2k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R10: 330; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder

Connections:
+3V3: R10.2; also elsewhere on the board
+12L: Conn1.2 (V+Log); also elsewhere on the board
/H-Bridge/Gripper1: Conn6.2 (V+Log), R9.1; also elsewhere on the board
/H-Bridge/Gripper2: Conn6.1 (GND), R14.1; also elsewhere on the board
GND: Conn1.1 (GND), Conn2.1 (GND), Conn3.1 (GND), Conn4.1 (GND), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K); also elsewhere on the board
unnamed: D2.2 (A), R9.2
unnamed: D3.2 (A), R11.2
unnamed: D4.2 (A), R12.2
unnamed: D5.2 (A), R13.2
unnamed: D6.2 (A), R10.1
unnamed: D7.2 (A), R14.2

Notes on the sheet:
Armboard Rev1
Green

Parts:
10uF1: C2; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
10uF2: C3; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
10uF3: C4; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
10uF4: C5; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
47uF1: CP1; CP_Radial_D5.0mm_P2.50mm
47uF2: CP2; CP_Radial_D5.0mm_P2.50mm
.1uF1: C1; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C3: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J1: Test_Point; TestPoint_Pad_3.0x3.0mm
U1: OKI; OKI_Horizontal

Connections:
+3V3: C3.1, J1.1, U1.3 (Vo); also elsewhere on the board
+12L: C2.1, U1.1 (Vi); also elsewhere on the board
GND: 10uF1.2, 10uF2.2, 10uF3.2, 10uF4.2, 47uF1.2, 47uF2.2, .1uF1.2, C2.2, C3.2, U1.2 (GND); also elsewhere on the board

Notes on the sheet:
Capacitor Train
Power
OKI

Parts:
U2: TM4C129E_Launchpad; TM4C129E_Launchpad_FULL_SMD_BOTTOM

Connections:
+3V3: U2.+3V3 (A1_1), U2.+3V3' (A2_1); also elsewhere on the board
Enc_1_PWM: U2.PL4 (C1_5); also elsewhere on the board
Enc_2_PWM: U2.PL5 (C1_6); also elsewhere on the board
Enc_3_PWM: U2.PM0 (C2_4); also elsewhere on the board
Enc_4_PWM: U2.PM1 (C2_5); also elsewhere on the board
Enc_5_PWM: U2.PM2 (C2_6); also elsewhere on the board
Enc_6_PWM: U2.PD3 (A1_7); also elsewhere on the board
GND: U2.GND (B1_2); also elsewhere on the board
IN_A: U2.PP3 (D2_8); also elsewhere on the board
IN_B: U2.PQ1 (D2_9); also elsewhere on the board
I_SENSE: U2.PD1 (D1_6); also elsewhere on the board
LS_1: U2.PA4 (B2_9); also elsewhere on the board
LS_2: U2.PA5 (B2_10); also elsewhere on the board
LS_3: U2.PB2 (A1_9); also elsewhere on the board
LS_4: U2.PB3 (A1_10); also elsewhere on the board
M_PWM: U2.PM6 (D2_10); also elsewhere on the board
Motor_1: U2.PD7 (B1_7); also elsewhere on the board
Motor_2: U2.PA6 (B1_8); also elsewhere on the board
Motor_3: U2.PM4 (B1_9); also elsewhere on the board
Motor_4: U2.PM5 (B1_10); also elsewhere on the board
Motor_5: U2.PD0 (D1_7); also elsewhere on the board
Motor_6: U2.PN2 (D1_8); also elsewhere on the board
Rx_1_Tiva: U2.PC4 (A1_3); also elsewhere on the board
Rx_2_Tiva: U2.PK0 (B2_5); also elsewhere on the board
Rx_3_Tiva: U2.PP0 (A2_3); also elsewhere on the board
Software_1: U2.PP4 (A2_8); also elsewhere on the board
Software_2: U2.PN5 (A2_9); also elsewhere on the board
Software_3: U2.PN4 (A2_10); also elsewhere on the board
Tx_1_Tiva: U2.PC5 (A1_4); also elsewhere on the board
Tx_2_Tiva: U2.PK1 (B2_6); also elsewhere on the board
Tx_3_Tiva: U2.PP1 (A2_4); also elsewhere on the board

Notes on the sheet:
Tiva Pinout
Serial 6
Serial 7
Serial 4

Parts:
Conn8, Conn9, Conn10, Conn11, Conn12, Conn13: Molex_SL_03; MOLEX_SL_03_Vertical
D9, D10, D11, D12, D13, D14, D15, D16, D17: LED; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R15, R16, R17, R18, R19, R20, R21, R22, R23: 330; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
+3V3: Conn8.1, Conn9.1, Conn10.1, Conn11.1, Conn12.1, Conn13.1; also elsewhere on the board
Enc_1_PWM: Conn8.3, R15.1; also elsewhere on the board
Enc_2_PWM: Conn9.3, R16.1; also elsewhere on the board
Enc_3_PWM: Conn10.3, R17.1; also elsewhere on the board
Enc_4_PWM: Conn11.3, R18.1; also elsewhere on the board
Enc_5_PWM: Conn12.3, R19.1; also elsewhere on the board
Enc_6_PWM: Conn13.3, R20.1; also elsewhere on the board
GND: Conn8.2, Conn9.2, Conn10.2, Conn11.2, Conn12.2, Conn13.2, D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K); also elsewhere on the board
unnamed: D9.2 (A), R15.2
unnamed: D10.2 (A), R16.2
unnamed: D11.2 (A), R17.2
unnamed: D12.2 (A), R18.2
unnamed: D13.2 (A), R19.2
unnamed: D14.2 (A), R20.2
unnamed: D15.2 (A), R21.1
unnamed: D16.2 (A), R22.1
unnamed: D17.2 (A), R23.1
Software_1: R21.2; also elsewhere on the board
Software_2: R22.2; also elsewhere on the board
Software_3: R23.2; also elsewhere on the board

Notes on the sheet:
Enc_2
Enc_3
Enc_4
Enc_5
Enc_6
Encoders and Software
Enc_1
Yellow
Blue

Parts:
Conn14, Conn15, Conn16, Conn17: Molex_SL_02
D18, D19, D20, D21, D22, D23, D24, D25, D26, D27: LED
R24, R25, R26, R27, R28, R29, R30, R31, R32, R33: 330; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
SW1, SW2, SW3, SW4, SW5, SW6: SW_Push

Connections:
+3V3: Conn14.1, Conn15.1, Conn16.1, Conn17.1, SW1.1, SW2.1, SW3.1, SW4.1, SW5.1, SW6.1; also elsewhere on the board
GND: D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K); also elsewhere on the board
LS_1: Conn14.2, R30.1; also elsewhere on the board
LS_2: Conn15.2, R31.1; also elsewhere on the board
LS_3: Conn16.2, R32.1; also elsewhere on the board
LS_4: Conn17.2, R33.1; also elsewhere on the board
Motor_1: R24.2, SW1.2; also elsewhere on the board
Motor_2: R25.2, SW2.2; also elsewhere on the board
Motor_3: R26.2, SW3.2; also elsewhere on the board
Motor_4: R27.2, SW4.2; also elsewhere on the board
Motor_5: R28.2, SW5.2; also elsewhere on the board
Motor_6: R29.2, SW6.2; also elsewhere on the board
unnamed: D18.2 (A), R24.1
unnamed: D19.2 (A), R25.1
unnamed: D20.2 (A), R26.1
unnamed: D21.2 (A), R27.1
unnamed: D22.2 (A), R28.1
unnamed: D23.2 (A), R29.1
unnamed: D24.2 (A), R30.2
unnamed: D25.2 (A), R31.2
unnamed: D26.2 (A), R32.2
unnamed: D27.2 (A), R33.2

Notes on the sheet:
Yellow
Limit Switches and Buttons
Limit Switches
Buttons

Parts:
Conn18, Conn19, Conn20: Molex_SL_03
D28, D29, D30, D31, D32, D33: LED
R34, R35, R36, R37, R38, R39: 330; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder

Connections:
GND: Conn18.2, Conn19.2, Conn20.2, D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K); also elsewhere on the board
unnamed: D28.2 (A), R34.1
unnamed: D29.2 (A), R35.2
unnamed: D30.2 (A), R36.1
unnamed: D31.2 (A), R37.2
unnamed: D32.2 (A), R38.1
unnamed: D33.2 (A), R39.2
Rx_1_Tiva: Conn18.1, R34.2; also elsewhere on the board
Rx_2_Tiva: Conn19.1, R36.2; also elsewhere on the board
Rx_3_Tiva: Conn20.1, R38.2; also elsewhere on the board
Tx_1_Tiva: Conn18.3, R35.1; also elsewhere on the board
Tx_2_Tiva: Conn19.3, R37.1; also elsewhere on the board
Tx_3_Tiva: Conn20.3, R39.1; also elsewhere on the board

Notes on the sheet:
Serial Pins
Purple

Parts:
C1: 33nF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D1: D_Zener; D_SOD-323_HandSoldering
Gripper_Motor1: VNH5019A_E; MultiPowerSO_30
R1, R2, R4, R6, R7, R8: 1k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R3: 0; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R5: 10k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder

Connections:
+3V3: R2.1, R3.1, R7.1; also elsewhere on the board
/H-Bridge/Gripper1: Gripper_Motor1.1 (OUT_A), Gripper_Motor1.25 (OUT_A), Gripper_Motor1.30 (OUT_A), Gripper_Motor1.31 (OUT_A_HEATSLUG); also elsewhere on the board
/H-Bridge/Gripper2: Gripper_Motor1.15 (OUT_B), Gripper_Motor1.16 (OUT_B), Gripper_Motor1.21 (OUT_B), Gripper_Motor1.33 (OUT_B_HEATSLUG); also elsewhere on the board
GND: C1.2, D1.2 (A), Gripper_Motor1.18 (GND), Gripper_Motor1.19 (GND), Gripper_Motor1.20 (GND), Gripper_Motor1.26 (GND), Gripper_Motor1.27 (GND), Gripper_Motor1.28 (GND), R6.2; also elsewhere on the board
IN_A: R1.1; also elsewhere on the board
IN_B: R8.1; also elsewhere on the board
I_SENSE: C1.1, D1.1 (K), R5.1; also elsewhere on the board
M_PWM: R4.1; also elsewhere on the board
unnamed: Gripper_Motor1.4 (IN_A), R1.2
unnamed: Gripper_Motor1.5 (EN_A/DIAG_A), R2.2
unnamed: Gripper_Motor1.6 (CS_DIS), R3.2
unnamed: Gripper_Motor1.7 (PWM), R4.2
unnamed: Gripper_Motor1.8 (CS), R5.2, R6.1
unnamed: Gripper_Motor1.9 (EN_B/DIAG_B), R7.2
unnamed: Gripper_Motor1.10 (IN_B), R8.2

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
Board: 2 copper layers, 125.5 x 100.8 mm, 109 parts (5 on the bottom side), 73 nets.

File Documentation/Armboard BOM.xlsx:

Id | Designator | Package | Designation |  | Item Name | Part Number |  |  | Vendor | Quantity | Cost Per Item |  | Cost | URL | Comments | Quantity
 | U2 | TM4C129E_Launchpad_FULL_SMD_BOTTOM | TM4C129E_Launchpad |  | LAUNCHPAD TM4C129E EVAL BRD | 296-44249-ND |  |  | Digikey | 1 | 29.99 |  | 29.99 | EK-TM4C129EXL Texas Instruments | Development Boards, Kits, Programmers | DigiK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
 | 47uF2,47uF1 | CP_Radial_D5.0mm_P2.50mm | CP2 |  | CAP ALUM 47UF 20% 16V RADIAL | 493-15997-ND |  |  | Digikey | 1 | 0.26 |  | 0.26 | USR1C470MDD Nichicon | Capacitors | DigiKey
 | U1 | OKI_Horizontal | OKI |  | DC DC CONVERTER 3.3V 5W | 811-3014-ND |  |  | Digikey | 1 | 4.3 |  | 4.3 | https://www.digikey.com/product-detail/en/murata-power-solut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
 | C3,C2,10uF1,10uF2,10uF3,10uF4 | C_0603_1608Metric_Pad1.05x0.95mm_HandSolder | 10uF |  | CAP CER 10UF 10V X5R 0603 | 399-C0603C106M8PAC7411CT-ND |  |  | Digikey | 6 | 0.46 |  | 2.7600000000000002 | C0603C106M8PAC7411 KEMET | Capacitors | DigiKey
 | Conn20,Conn19,Conn18,Conn13,Conn12,Conn11,Conn10,Conn9,Conn8 | MOLEX_SL_03_Vertical | Molex_SL_03 |  | CONN HOUSING 3POS .100 W/LATCH | WM2901-ND |  |  | Digikey | 9 | set of 10 for $1.86 |  | 1.86 | https://www.digikey.com/products/en?keywords=WM2901-ND
 | Conn17,Conn16,Conn15,Conn14 | MOLEX_SL_02_Vertical | Molex_SL_02 |  | CONN HOUSING 2POS .100 W/LATCH | WM2900-ND |  |  | Digikey | 4 | 0.28999999999999998 |  | 1.1599999999999999 | https://www.digikey.com/products/en?keywords=WM2900-ND
 | SW6,SW5,SW4,SW3,SW2,SW1 | SW_Push_1P1T_NO_6x6mm_H9.5mm | SW_Push |  | SWITCH TACTILE SPST-NO 0.05A 24V | 450-2058-1-ND |  |  | Digikey | 6 | 0.37 |  | 2.2199999999999998 | FSM6JSMATR TE Connectivity ALCOSWITCH Switches | Switches | DigiKey
 | R39,R38,R37,R36,R35,R34,R33,R32,R31,R30,R29,R28,R27,R26,R25,R24,R23,R22,R21,R20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 | R_0603_1608Metric_Pad1.05x0.95mm_HandSolder | 330 |  | RES SMD 330 OHM 5% 1/4W 0603 | RHM330DCT-ND |  |  | Digikey | 26 | 3 sets of 10 for $0.74 each |  | 2.2199999999999998 | ESR03EZPJ331 Rohm Semiconductor | Resistors | DigiKey
 | R14,R13,R12,R11,R9 | R_0603_1608Metric_Pad1.05x0.95mm_HandSolder | 1.2k |  | RES SMD 1.2K OHM 5% 1/4W 0603 | RHM1.2KDCT-ND |  |  | Digikey | 5 | 0.1 |  | 0.5 | ESR03EZPJ122 Rohm Semiconductor | Resistors | DigiKey
 | R8,R7,R6,R4,R2,R1 | R_0603_1608Metric_Pad1.05x0.95mm_HandSolder | 1k |  | RES SMD 1K OHM 5% 1/4W 0603 | RHM1.0KDCT-ND |  |  | Digikey | 6 | 0.1 |  | 0.60000000000000009 | https://www.digikey.com/product-detail/en/rohm-semiconductor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
 | R5 | R_0603_1608Metric_Pad1.05x0.95mm_HandSolder | 10k |  | RES SMD 10K OHM 1% 1/4W 0603 | RHM10KADCT-ND |  |  | Digikey | 1 | 0.12 |  | 0.12 | https://www.digikey.com/product-detail/en/rohm-semiconductor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
 | R3 | R_0603_1608Metric_Pad1.05x0.95mm_HandSolder | 0 |  | RES SMD 0 OHM JUMPER 1/10W 0603 | 311-0.0GRCT-ND |  |  | Digikey | 1 | 0.1 |  | 0.1 | https://www.digikey.com/products/en?keywords=311-0.0GRCT-ND
 | Gripper_Motor1 | MultiPowerSO_30 | VNH5019A_E |  | IC MTR DRV 5.5-24V MULTIPWRSO-30 | 497-13073-1-ND |  |  | Digikey | 1 | 7.68 |  | 7.68 | VNH5019A-E STMicroelectronics | Integrated Circuits (ICs) | DigiKey
 | D6,D3,D4,D5,D2,D7 | LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder | LED |  | LED GREEN CLEAR SMD | 160-1446-1-ND |  |  | Digikey | 6 | 0.26 |  | 1.56 | https://www.digikey.com/product-detail/en/lite-on-inc/LTST-C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
 | D9,D10,D11,D12,D13,D14,D18,D19,D20,D21,D22,D23,D24,D25,D26,D27 | LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder | LED |  | LED YELLOW CLEAR SMD | 160-1448-1-ND |  |  | Digikey | 16 | 2 sets of 10 for $1.51 each |  | 3.02 | https://www.digikey.com/product-detail/en/lite-on-inc/LTST-C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
 | D15,D16,D17,D28,D29,D30,D31,D32,D33 | LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder | LED |  | LED BLUE CLEAR CHIP SMD | 160-1647-1-ND |  |  | Digikey | 9 | set of 10 for $2.62 |  | 2.62 | https://www.digikey.com/product-detail/en/lite-on-inc/LTST-C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
 | D1 | D_SOD-323_HandSoldering | D_Zener |  | DIODE ZENER 12V 200MW SOD323 | BZX384C12-HE3-08GICT-ND |  |  | Digikey | 1 | 0.25 |  | 0.25 | BZX384C12-HE3-08 Vishay Semiconductor Diodes Division | Discrete Semiconductor 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
 | C1 | C_0603_1608Metric_Pad1.05x0.95mm_HandSolder | 33nF |  | CAP CER 0.033UF 16V X7R 0603 | 399-C0603C333K4RACAUTOCT-ND |  |  | Digikey | 1 | 0.12 |  | 0.12 | C0603C333K4RACAUTO KEMET | Capacitors | DigiKey
 | .1uF1 | C_0603_1608Metric_Pad1.05x0.95mm_HandSolder | C1 |  | CAP CER 0.1UF 16V X7R 0603 | 1276-1005-1-ND |  |  | Digikey | 1 | 0.1 |  | 0.1 | https://www.digikey.com/product-detail/en/samsung-electro-me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
 | Conn1,Conn4,Conn3,Conn2,Conn6 | Anderson_2_Vertical_Sidy_by_Side,Anderson_3_Ho Anderson PP | AndersonPP |  | Black Anderson Housing | 1327G6 |  |  | Powerwerx | 4 | 0.37 |  | 1.48 | Anderson Power Products 1327 series PP15/30/45 Powerpole Connector Colored Hous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
 |  |  |  |  | Red Anderson Housing | 1327 |  |  | Powerwerx | 7 | 0.37 |  | 2.59 | Anderson Power Products 1327 series PP15/30/45 Powerpole Connector Colored Hous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
 |  |  |  |  | 15A Contact | 1332 |  |  | Powerwerx | 11 | 0.18 |  | 1.98 | 1332-BK Anderson Power PP15 Powerpole Connector Contact, 16-20 GA, 15A, Loose P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
 |  |  |  |  | Vertical Mount | 1335G1 |  |  | Powerwerx | 8 | 0.59 |  | 4.72 | Anderson Power 1335G1 Printed Circuit Board High Power 45 Amp Vertical Contact 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
 |  |  |  |  | Horizontal Mount | 1336G1 |  |  | Powerwerx | 3 | 0.55000000000000004 |  | 1.6500000000000001 | Anderson Power 1336G1 Printed Circuit Board High Power 45 Amp Horizontal Bottom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

## Commit log

2020-09-11 Created Project
2020-09-11 Created proper page size and one hierarchal sheet for indicators
2020-09-20 Added Capacitor Train to Power Heirarchal sheet
2020-09-20 Added Anderson connectors to power section
2020-09-20 Power Board Schematic Update
2020-09-20 Added OKI to power
2020-09-29 Put Anderson connectors on front page, replaced OKI with Buckman converter
2020-09-29 Added empty heirarchical sheets
2020-09-30 Added nothing
2020-09-30 Added TIVA Device and changed page sizes
2020-10-03 Added, Solenoid actuation, laser control, and encoders
2020-10-08 H-Bridge completed
    Completed the H-Bridge Hierarchal Sheet
2020-10-12 Added serial pins, limit switches, titles, and indicators
2020-10-12 Tiva Updates
2020-10-12 Formatted GNDs and added motor toggle buttons
2020-10-12 Updated H-Bridge
    Made the appropriate changes suggested by anthony in slack chat regarding the H-Bridge's flaws
2020-10-13 Moved I/O outside of Power block
2020-10-20 Zener fix
    Replaced the schotkey diode or however you spell it, with the zener diode
2020-10-22 Fixed buttons/switches page, changed resistor values, fixed some tiva connections
2020-10-25 Added TIVA pins to H-Bridge
    Added the missing TIVA pins to the H-Bridge
2020-10-25 Review 2 board changes
    -Connected the busses on the power and H-Bridge
    -Changed the resistor value to 1.2k
    -Fixed some of the pin locations on the TIVA
    -Added ferrites to the H-Bridge
    -Connected the buses so that they all highlight correctly
2020-10-29 Fixed changes from review 2 of circuit board
    except the LED indicators
2020-10-29 Added Software LEDs
2020-10-29 Fixed software flags
2020-11-10 Deleted laser and solenoid
2020-11-10 Attempted to add 12 VL line
2020-11-10 Assigned R/L/C footprints
2020-11-13 Added more footprints
2020-11-13 Imported footprints to layout
2020-11-13 Fixed Andersons, made netlist, imported footprints to layout
2020-11-13 Set board dimensions and started layout
2020-11-14 Added buckman and power leds to layout
2020-11-14 Added more components to layout
2020-11-15 Finished general component layout
2020-11-16 Made more connections to tiva
2020-11-16 Added more tiva connections. Moved LS connectors away from tiva pins. Started moving ENC connectors away from tiva pins.
2020-11-16 Finished tiva connections
2020-11-16 Added ground planes
2020-11-20 Double-checked schematic, pointed power pins up, made sure 12V and 3.3V were full networks
2020-11-20 Replaced buckman with OKI
2020-11-20 Updated footprints, generated new netlist
2020-11-20 Started updating layout. Connected edge cuts
2020-11-20 Routed 12VL and 12VA zones. Done?
2020-11-20 Rounded edge cuts, added silkscreen header
2020-11-20 Added silkscreen designs
2020-11-21 Added more labels, fixed 12VA/12L connections, filled gnd islands, +/-/S labels, added drillhole footprints
2020-11-21 vias
2020-11-21 less vias
2020-11-21 moved some labels around, added rx/tx pin labels
2020-11-24 Created BOM
2020-11-24 Updated BOM
2020-11-24 Completed BOM
2020-11-24 Completed Gerbs
2020-11-24 Created Tiva pinout png and STEP files
2020-11-24 Deleted BOM template file
2020-11-25 Moved gerbs to documentation folder
2020-11-26 Fixed some library issues and moved Gerbs to Manufacturing folder
2020-11-26 Deleted extra project file

Notices in the files:
parts and their libraries:
Copyright 2016 Accelerated Designs. All rights reserved.
